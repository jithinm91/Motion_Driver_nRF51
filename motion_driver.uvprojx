# Keil uVision project motion_driver.uvprojx, settings and files
target nrf51422 (5060020::V5.06 (build 20)::ARMCC)
  device: nRF51422_xxAC Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.0.3
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: motion_driver
  c flags: Optim=4 OneElfS=1
  c define: MOTION_DRIVER_TARGET_NRF51 MPU9150
  c misc: --c99
  c include: .\Core\driver\eMPL;.\Core\driver\include;.\Core\eMPL-hal;.\Core\mllite;.\Core\mpl;..\Motion_Driver_nrf51
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application
    ./: main.c mpu9150.c
  group Driver
    ./Core/driver/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
software components: CMSIS:CORE 4.1.0, Device:Startup 8.0.3, nRF_BLE:BLE_Modules:ble_advdata 3.0.1, nRF_BLE:BLE_Modules:ble_common 3.0.1, nRF_BLE:BLE_Modules:ble_conn_params 3.0.1, nRF_BLE:BLE_Modules:ble_service_common 3.0.1, nRF_Drivers:nrf_delay 3.0.1, nRF_Drivers:nrf_error 3.0.1, nRF_Drivers:nrf_gpio 3.0.1, nRF_Drivers:twi_master 3.0.1, nRF_Libraries:app_error 3.0.1, nRF_Libraries:app_timer 3.0.1, nRF_Libraries:app_util 3.0.1, nRF_SoftDevice:Internal:sd_common 1.1.4, nRF_SoftDevice:Internal:softdevice_present 1.1.4, nRF_SoftDevice:s110 8.0.2
